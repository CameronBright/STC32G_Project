# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: LED +hex
  group User
    ./: main.c
    ./OLED/: oled.c
  group Meun
    ./Menu/: Meun.c
  group Key
    ./Encoders/: Encoders.c
    ./Key/: key.c
  group timer
    ./timer/: timer.c
  group Uart
    ./Uart/: Uart.c
  group iic
    ./iic/: iic.c
  group PWM
    ./PWM/: pwm.c
  group GPIO
    ./GPIO/: GPIO.c
  group motor
    ./motor/: motor.c
  group ADC
    ./ADC/: ADC.c
  group LineFollower
    ./LineFollower/: LineFollower.c
  group MPU6050
    ./MPU6050/: MPU6050.c
